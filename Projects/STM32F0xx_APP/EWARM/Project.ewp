# IAR project Project.ewp, settings and files
configuration app_b (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030RC ST STM32F030RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_STM320518_EVAL; STM320518_EVAL_REVB; LSI_TIM_MEASURE; APP_B=1
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Utilities\Third_Party\FreeRTOSv10.0.0\FreeRTOS\Source\include; ..\..\..\Utilities\Third_Party\FreeRTOSv10.0.0\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_Cryptographic_Library\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM320518_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: V2_0.1.7.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: stm32f0xx_flash_b.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration app_a (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_STM320518_EVAL; STM320518_EVAL_REVB; LSI_TIM_MEASURE; APP_A=1
  OBJCOPY.OOCOutputFile: V1_0.1.7.bin
  ILINK.IlinkIcfFile: stm32f0xx_flash_a.icf
configuration bootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_STM320518_EVAL; STM320518_EVAL_REVB; LSI_TIM_MEASURE; BOOTLOADER=1
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: V0_0.1.7.bin
  ILINK.IlinkIcfFile: stm32f0xx_flash_bootloader.icf
  group CMSIS
    ../src/: system_stm32f0xx.c
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group FreeRTOS
    ../../../Utilities/Third_Party/FreeRTOSv10.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable
    ../../../Utilities/Third_Party/FreeRTOSv10.0.0/FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
    ../../../Utilities/Third_Party/FreeRTOSv10.0.0/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group IAP
    ../src/: common.c flash_if.c menu.c ymodem.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group STM32_Cryptographic_Library
    ../../../Libraries/STM32_Cryptographic_Library/binary/EWARM/: M0_CryptoFW_2_0_6.a
  group STM32_EVAL
    ../../../Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c
  group User
    ../src/: adc.c crc_soft.c e2prom.c gprs.c i2c_soft.c led.c main.c protocol.c rtc.c serial.c stm32f0xx_it.c
    ../inc/: FreeRTOSConfig.h
    ./: stm32f0xx_flash_a.icf stm32f0xx_flash_b.icf stm32f0xx_flash_bootloader.icf
